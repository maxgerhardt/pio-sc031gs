## sdkconfig.defaults
```kconfig
# Enable PSRAM and the camera
CONFIG_ESP32_SPIRAM_SUPPORT=y
CONFIG_SC031GS_SUPPORT=y
```
